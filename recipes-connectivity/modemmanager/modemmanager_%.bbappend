RDEPENDS:${PN} += "glibc-gconv-utf-16"
