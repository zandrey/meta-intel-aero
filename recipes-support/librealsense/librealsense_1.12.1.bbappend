FILES:${PN} += "${includedir}/${PN}"
